FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-update-bootcmd.patch" 
